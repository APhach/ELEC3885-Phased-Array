options:
  parameters:
    author: ariya
    generate_options: qt_gui
    id: validation_flow
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '2215920000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Rcv Gain
    start: '0'
    step: '1'
    stop: '80'
    value: '23'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {state: disabled}
- name: noise_voltage
  id: variable
  parameters:
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: 0.0314*2
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1670000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    label: Tx Attenuation
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: temp_bits.bin
    type: byte
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: qpsk_test_receive.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: temp_symbols.bin
    type: complex
  states: {}
- name: blocks_file_sink_1_1_0
  id: blocks_file_sink
  parameters:
    file: debug_bits.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: qpsk_transmit.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(qpsk.points())
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '15'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: qpsk.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, frame_len=255, preamble_len=384):
              gr.basic_block.__init__(self,
                  name="Custom CCSDS TX",
                  in_sig=[np.uint8],
                  out_sig=[np.float32])
              self.frame_len = frame_len
              self.preamble_len = preamble_len
              self.asm_val = 0x1ACFFC1D
              self.asm_bits = [(self.asm_val >> (31 - i)) & 1 for i in range(32)]
              
              # Pre-generate a fixed random sequence for the preamble
              # This prevents loop-shock when transitioning to the scrambled payload
              np.random.seed(42) 
              self.preamble_bits = np.random.randint(0, 2, self.preamble_len)
              
              self.out_frame_size = self.preamble_len + 32 + (self.frame_len * 8)

          def general_work(self, input_items, output_items):
              in_sig = input_items[0]
              out_sig = output_items[0]
              in_idx = 0
              out_idx = 0

              while (in_idx + self.frame_len <= len(in_sig)) and \
                    (out_idx + self.out_frame_size <= len(out_sig)):

                  data = in_sig[in_idx : in_idx + self.frame_len]
                  in_idx += self.frame_len

                  # 1. Preamble
                  for b in self.preamble_bits:
                      out_sig[out_idx] = 1.0 if b else -1.0
                      out_idx += 1

                  # Reset LFSR at start of every frame payload so RX stays in sync
                  lfsr = 0xFF

                  # 2. ASM (unscrambled)
                  for b in self.asm_bits:
                      out_sig[out_idx] = 1.0 if b else -1.0
                      out_idx += 1

                  # 3. Payload (scrambled)
                  for byte in data:
                      for i in range(7, -1, -1):
                          bit = (byte >> i) & 1
                          msb = (lfsr >> 7) & 1
                          enc_bit = bit ^ msb
                          out_sig[out_idx] = 1.0 if enc_bit else -1.0
                          out_idx += 1

                          new_bit = (
                              ((lfsr >> 7) & 1) ^
                              ((lfsr >> 6) & 1) ^
                              ((lfsr >> 4) & 1) ^
                              ((lfsr >> 2) & 1)
                          )
                          lfsr = ((lfsr << 1) | new_bit) & 0xFF

              self.consume(0, in_idx)
              return out_idx
    frame_len: frame_len
    preamble_len: '384'
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, frame_len=255, tolerance=0):
              gr.basic_block.__init__(self,
                  name="Custom CCSDS RX",
                  in_sig=[np.float32],
                  out_sig=[np.uint8])
              self.frame_len = frame_len
              self.tolerance = tolerance
              self.asm_val = 0x1ACFFC1D
              self.state = 0          # 0 = hunting, 1 = receiving payload
              self.sync_reg = 0
              self.lfsr = 0xFF
              self.bit_count = 0
              self.current_byte = 0
              self.frames_seen = 0

          def general_work(self, input_items, output_items):
              in_sig = input_items[0]
              out_sig = output_items[0]
              in_idx = 0
              out_idx = 0

              while in_idx < len(in_sig) and out_idx < len(out_sig):
                  bit = 1 if in_sig[in_idx] > 0 else 0

                  if self.state == 0:
                      # Shift incoming bits into 32-bit sync register
                      self.sync_reg = ((self.sync_reg << 1) | bit) & 0xFFFFFFFF
                      diff = self.sync_reg ^ self.asm_val
                      errors = bin(diff).count('1')

                      if errors <= self.tolerance:
                          self.state = 1
                          self.bit_count = 0
                          self.current_byte = 0
                          self.lfsr = 0xFF
                          self.frames_seen += 1
                          print(f"[RX] ASM detected, frame #{self.frames_seen}, errors={errors}")

                  else:  # state == 1: descramble payload
                      msb = (self.lfsr >> 7) & 1
                      orig_bit = bit ^ msb
                      self.current_byte = ((self.current_byte << 1) | orig_bit) & 0xFF

                      new_bit = (
                          ((self.lfsr >> 7) & 1) ^
                          ((self.lfsr >> 6) & 1) ^
                          ((self.lfsr >> 4) & 1) ^
                          ((self.lfsr >> 2) & 1)
                      )
                      self.lfsr = ((self.lfsr << 1) | new_bit) & 0xFF
                      self.bit_count += 1

                      if self.bit_count % 8 == 0:
                          out_sig[out_idx] = self.current_byte
                          out_idx += 1
                          self.current_byte = 0

                      if self.bit_count == self.frame_len * 8:
                          self.state = 0
                          self.sync_reg = 0

                  in_idx += 1

              self.consume(0, in_idx)
              return out_idx
    frame_len: frame_len
    tolerance: '1'
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: (int)(frequency)
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: (int)(frequency)
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: Synced Only
    label2: Synced & Phase-Locked
    name: Synced Constellation
    nconnections: '2'
    size: '1024'
    type: complex
    update_time: '0.05'
    width2: '2'
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ssync"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"costas"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.qpsk.set_npwr(1.0)
    section: main_after_init
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_file_sink_1_0, '0']
- [blocks_add_const_vxx_1, '0', epy_block_0_0_1, '0']
- [blocks_add_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_file_source_0, '0', epy_block_0_0_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_1_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_add_xx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_1_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_1_0, '0']
- [digital_glfsr_source_x_0, '0', epy_block_0_0_0_0, '0']
- [digital_map_bb_1_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0_1, '0', blocks_file_sink_1, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', filter_fft_rrc_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
